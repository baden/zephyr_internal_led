## Kconfig
```kconfig
config INTERNAL_LED_DRIVER
    bool "Intrernal LED for most Baden's devices."
    default n
```
